Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-29T16:56:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 29 16:56:36 2022 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{D2A04E5A-DA5D-4C57-83F0-6290940B06CF}\ifc * Database version: 5507 * Database creation date: Tue Nov 29 16:56:34 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 29 16:56:34 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 29 16:56:34 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7402C Shower system, 7402C(2022):7402C Shower system:358119
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - ShowerDefaultElevation: 900 mm
Type - Dimensions - NominalDepth: 545.692 mm; NominalHeight: 1162.51 mm; NominalWidth: 291.051 mm
Type - General - Author: BIMStone; BIMObjectName: 7402C(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 23/11/2022
Type - Green Building Properties - EAN Number: 6414150100802; EN Standard: EN 1111; ETIM Class Number: EC011329 Shower mixing tap; LVI Number: 6310893; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4202684; RSK Number: 8283224; Sales Package dimensions (LxWxH): 1154 x 383 x 98; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/7402C; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/7402C; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7402C; 3D View: https://static.oras.com/AR/7402C; Catalog Drawing URL: http://static.oras.com/catdrw/7402C; Dimension Drawing URL: http://static.oras.com/dimdrw/7402C; FDV Document URL: http://www.oras.com/datasheet/7402C/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7402C; Group: Shower system; Installation and Maintenance Guide URL: http://static.oras.com/manual/7402C; Interactive AR View URL: https://static.oras.com/AR/7402C; Manufacturer: Oras; Market: International;Norway; Mobile Product Information URL: http://mpi.oras.com/7402C; Model: 7402C Shower system; Name_en: 7402C Shower system; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7402C; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7402C; Product URL: http://static.oras.com/7402C; Spare-Part Information URL: http://static.oras.com/sp/7402C; Technical DataSheet URL: http://www.oras.com/datasheet/7402C/en; Type Name: 7402C Shower system; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Flexible length / can be shortened; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread; Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.0105944 m3/s; Hand Shower Size: Ø 95 mm; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;;Non-return valve(s);Litter filter(s); Over Head Shower Size: Ø 200 mm; Pressure Loss With Flow 02ls: 180000 Pa; Shower Parts: Hand shower;Shower rail;Overhead shower;Adjustable shower rail bracket;Shower hose (1750 mm);Variable fixing points;Rotatable ball joint connection;Anti limescale technology (easy to clean); Shower Spray: Intense; Shower Spray Number: 1 shower spray; Spout Projection: 435 - 460 mm; Surface treatment: Chrome; Temperature: Thermostatic safety stop at 38°C;THERMO COOL; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7402C(2022); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7402C; Name: 7402C Shower system; ReplacementCost: n/a; Shape: Sculptured; Size: 290x545x1165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7402C; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7402C Shower system
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 1.13518 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.184666 m3
Identity Data - Mark: 6
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7402C(2022): 7402C Shower system; Family and Type: 7402C(2022): 7402C Shower system; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7402C(2022): 7402C Shower system; Type Id: 7402C(2022): 7402C Shower system; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
